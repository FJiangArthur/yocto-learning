# Copy of hello-world recipe in the layer structure
require recipes/hello-world_1.0.bb
